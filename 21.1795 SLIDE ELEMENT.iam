# Autodesk Inventor assembly: 21.1795 SLIDE ELEMENT
## iProperties
Created: 2007-05
Part Number: 21.1795 SLIDE ELEMENT
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
